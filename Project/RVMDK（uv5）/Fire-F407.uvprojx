# Keil uVision project Fire-F407.uvprojx, settings and files
target SRAM (ARM-ADS)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\STemWin\inc;..\..\STemWin\Config;..\..\User\app;..\..\User\TIMER;..\..\User\interaction;..\..\User\MAX31865;..\..\User\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../User/: startup_stm32f40xx.s
  group CMSIS
    ../../User/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/led/: bsp_led.c
    ../../User/beep/: bsp_beep.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/key/: bsp_key.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/TouchPad/: bsp_touchpad.c
    ../../User/lcd/: bsp_nt35510_lcd.c
    ../../User/touch/: bsp_i2c_touch.c gt9xx.c
    ../../User/usart/: bsp_debug_usart.c
  group STemWIN
    ../../STemWin/Config/: GUIConf.c GUIConf.h GUIDRV_Template.c
    ../../STemWin/OS/: GUI_X.c
    ../../STemWin/Lib/: STemWin_CM4_wc16_ot_ARGB.a
  group DOC
    ../../: 必读说明.txt
  group APP
    ../../User/app/: GlobalVar.c WindowDLG.c Font45.c
    ../../User/TIMER/: timer.c
    ../../User/: gpio.c temp_ctrl.c
    ../../User/MAX31865/: max31865.c
    ../../User/PWM/: pwm.c
  group INTERACTION
    ../../User/interaction/: keyboard.c oMenu.c Screen.c OLED.c
